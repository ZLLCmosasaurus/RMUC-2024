# Keil uVision project infantry.uvprojx, settings and files
target infantry (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: infantry +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\APP\pid;..\BSP\bsp_can;..\APP\chassis_move;..\APP\Kinematics;..\Core\Inc;..\APP\chassis_task;..\APP\remote_control;..\BSP\bsp_referee;..\APP\referee;..\components\support;..\APP\struct_typedef;..\APP\protocol;..\APP\fuzzy_pid;..\APP\supercap;..\APP\referee_ui;..\APP
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: dma.c my_init.c main.c gpio.c can.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group APP
    ../APP/pid/: pid.c
    ../APP/Kinematics/: kinematics.c
    ../APP/chassis_move/: chassis_move.c
    ../APP/chassis_task/: chassis_task.c
    ../APP/remote_control/: remote_control.c
    ../APP/referee/: referee.c
    ../APP/fuzzy_pid/: fuzzy_pid.c
    ../APP/supercap/: supercap.c
    ../APP/referee_ui/: referee_UI.c
    ../APP/: referee_cmd.c
  group BSP
    ../BSP/bsp_can/: bsp_can.c
    ../BSP/bsp_referee/: bsp_referee.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group components
    ../components/support/: fifo.c CRC8_CRC16.c
software components: CMSIS:CORE 4.3.0
